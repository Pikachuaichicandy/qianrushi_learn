#include "Delay.h" // Device header

void Delay_us(uint16_t us)
{
    RCC->APB1ENR |= RCC_APB1ENR_TIM6EN;

    TIM6->PSC = 72 - 1;

    TIM6->ARR = us - 1;

    TIM6->EGR |= TIM_EGR_UG;
    TIM6->SR &= ~TIM_SR_UIF;

    TIM6->CR1 |= TIM_CR1_CEN;

    //while(TIM6->CNT < us - 1);
    while((TIM6->SR & TIM_SR_UIF) == 0);
    TIM6->SR &= ~TIM_SR_UIF;
    TIM6->CR1 &= ~TIM_CR1_CEN;
}

void Delay_ms(uint16_t ms)
{
    RCC->APB1ENR |= RCC_APB1ENR_TIM6EN;

    TIM6->PSC = 7200 - 1;

    TIM6->ARR = 10 * ms - 1;

    TIM6->EGR |= TIM_EGR_UG;
    TIM6->SR &= ~TIM_SR_UIF;

    TIM6->CR1 |= TIM_CR1_CEN;

    //while(TIM6->CNT < us - 1);
    while((TIM6->SR & TIM_SR_UIF) == 0);
    TIM6->SR &= ~TIM_SR_UIF;
    TIM6->CR1 &= ~TIM_CR1_CEN;
}


void Delay_us_1(uint16_t us)
{
    /* 定时器重装�? */
    SysTick->LOAD = 72 * us;
    /* 清除当前计数�? */
    SysTick->VAL = 0;
    /*设置内部时钟源（2�?->1�?,不需要中断（1�?->0），并启动定时器(0�?->1)*/
    SysTick->CTRL = 0x5;
    /*等待计数�?0�? 如果计数�?0�?16位会置为1*/
    while (!(SysTick->CTRL & SysTick_CTRL_COUNTFLAG));
    /* 关闭定时�? */
    SysTick->CTRL &= ~SysTick_CTRL_ENABLE; 
}

void Delay_ms_1(uint16_t ms)
{
    while (ms--)
    {
        Delay_us(1000);
    }
}

void Delay_s(uint16_t s)
{
    while (s--)
    {
        Delay_ms(1000);
    }
}
