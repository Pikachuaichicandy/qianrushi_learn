# Keil uVision project 21_General_TImer_LCD_BG_Register.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\arm5_compiler)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: 01_LED_Register +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\Start;.\User;.\Driver\Led;.\Driver\usart;.\Driver\systick;.\Driver\timer;.\Driver\key
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Start
    ./Start/: core_cm3.c system_stm32f10x.c startup_stm32f10x_hd.s
  group User
    ./User/: main.c Delay.c
  group Driver
    ./Driver/Led/: Driver_LED.c
    ./Driver/usart/: Driver_USART.c
    ./Driver/systick/: Driver_SysTick.c
    ./Driver/timer/: Driver_TIM6.c Driver_TIM5.c Driver_TIM3.c
    ./Driver/key/: Driver_Key.c
